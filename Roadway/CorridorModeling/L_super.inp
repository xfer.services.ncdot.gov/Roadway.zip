 
auto shape
job number = RDY
 
   auto shape set
      shape cluster baseline   = L
      shape cluster profile    = L
      shape cluster tie        = 0.0000
      dependent shape
      chain  /  offset
           L        0.0000
           L      -12.0000
      filler line station / slope
         10+90.00		   0.0000
         11+32.00		   2.0000
         12+43.40			 2.0000
         12+85.40 		 4.0000
         20+78.45			 4.0000
         22+04.45			-2.0000
         22+29.00			-2.0000
         22+50.00			-1.6000
         
 
   auto shape set
      shape cluster baseline   = L
      shape cluster profile    = L
      shape cluster tie        = 0.0000
      dependent shape
      chain  /  offset
           L        0.0000
           L       14.0000
      filler line station / slope
         10+90.00		  -3.0000
         11+11.00		  -2.0000
         12+43.40			-2.0000
         12+85.40 		-4.0000
         20+78.45			-4.0000
         21+20.45			-2.0000
         22+29.00			-2.0000
         22+50.00			-2.4000
         
        