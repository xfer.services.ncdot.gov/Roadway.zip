
auto shape
job number = RDY
 
      auto shape set
      shape cluster baseline   = l
      shape cluster profile    = lpro
      shape cluster tie        = 0
      dependent shape
      chain  /  offset
         l        0
         l        11
      filler line station / slope
            13+27.49						-02
            14+71.49             04
            15+19.49						 06
            15+65.87             06
            16+61.87						 02
            19+30.20						 02
            20+26.20						 06
            24+13.28						 06
            25+57.28						 00
            26+00.00						 00
                                                                       
      auto shape set
      shape cluster baseline   = l
      shape cluster profile    = lpro
      shape cluster tie        = 0
      dependent shape
      chain  /  offset
         l        0
         l       -11
      filler line station / slope            
            14+23.49						 -02
            14+71.49             -04
            15+19.49						 -06
            15+65.87             -06
            16+61.87						 -02
            19+30.20						 -02
            20+26.20						 -06
            24+13.28						 -06
            25+09.28						 -02
            26+00.00						 -02
            
      Plot Parameters
      Dependent Shape
         lvname = Prop Geopak Pavement Shape Dependent
      Dependent Text
         lvname = Prop Geopak Pavement Shape Label
      Independent Shape
         lvname = Prop Geopak Pavement Shape Independent
      Independent Text
         lvname = Prop Geopak Pavement Shape Label
            
   Write shapes into dgn = r:\roadway\xsc\b5325_rdy_shp_l.dgn
   
   
            

      