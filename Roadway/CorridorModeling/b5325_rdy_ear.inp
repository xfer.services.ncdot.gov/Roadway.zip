XSECTION

Earthwork

tolerance = 0.01

xs dgn = b5325_rdy_xsc.DGN

Proposed Finish Grade
   soil type = suitable
   fill mult factor = 1.00
      type = line, line_string
      lvname = Prop CMT Slope Grass 
      lvname = Prop CMT Conc Surface
      lvname = Prop CMT Pvmt Surface
      lvname = Prop CMT Pvmt Surface Shoulder
      lvname = Prop CMT Subgrade Earthwork
      lvname = Exist CMT Pavement
      lvname = Prop CMT Ditch DDE

Existing Ground Line
   soil type = suitable
      type = line, line_string
      lvname = Exist XS Ground Line



Write Earthwork Shapes
   plot param
      lvname = Prop XS Earthwork Shape
      Stratify Shape Color

End Area Decimal Places = 0

process earthwork for baseline = L
   job number = rdy
   beginning station = 12+50.00
   ending station = 17+20.15

process earthwork for baseline = L
   job number = rdy
   beginning station = 18+52.65
   ending station = 26+50.00
